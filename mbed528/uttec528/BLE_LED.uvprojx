# Keil uVision project BLE_LED.uvprojx, settings and files
target uttec528 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: rfSet_180325_0800 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DNRF52_PAN_36 -DDEVICE_RTC=1 -DNRF52_PAN_12 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DNRF52_PAN_15 -DNRF52_PAN_30 -DTARGET_NRF5 --preinclude=mbed_config.h -DCONFIG_GPIO_AS_PINRESET -DBOARD_PCA10040 -D__ASSERT_MSG -DSWI_DISABLE0 --no_rtti -DDEVICE_STCLK_OFF_DURING_SLEEP=1 --split_sections -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" -DDEVICE_PORTINOUT=1 -DSOFTDEVICE_PRESENT -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DCMSIS_VECTAB_VIRTUAL -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_MCU_NRF52 -DTARGET_CORTEX_M -DNRF52_PAN_63 -DNRF52_PAN_62 -DDEVICE_PORTIN=1 -DARM_MATH_CM4 --apcs=interwork -DTARGET_MCU_NRF52832 -DNRF52_PAN_20 -DDEVICE_I2C=1 -DBLE_STACK_SUPPORT_REQD -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DTARGET_NRF52_COMMON -DTOOLCHAIN_ARM -DNRF52 -DMBED_TICKLESS -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DMBED_BUILD_TIMESTAMP=1513560983.6 --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 -DS132 --gnu -DTARGET_NRF52_DK -D__FPU_PRESENT=1 -DDEVICE_SPI=1 -D__MBED__=1 -DNRF52_PAN_31 -DFEATURE_BLE=1 -DTARGET_NORDIC -DNRF52_PAN_64 -DNRF52_PAN_54 -DNRF52_PAN_55 -DTARGET_M4 -DTARGET_NRF52832 -DNRF52_PAN_51 -DNRF52_PAN_53 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DNRF52_PAN_58 -D__MBED_CMSIS_RTOS_CM -DTARGET_SDK11
  c include: .;BLE_API;BLE_API/ble;BLE_API/ble/services;BLE_API/source;BLE_API/source/services;nRF51822;nRF51822/TARGET_NRF5;nRF51822/TARGET_NRF5/source;nRF51822/TARGET_NRF5/source/btle;nRF51822/TARGET_NRF5/source/btle/custom;nRF51822/TARGET_NRF5/source/common;mbed/.;mbed/TARGET_NRF52_DK;mbed/TARGET_NRF52_DK/TARGET_NORDIC;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/TARGET_NRF52_DK;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/pwm;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/saadc;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/nrf52;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/hex;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk_patch;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common;mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler;mbed/TARGET_NRF52_DK/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;.\UttecLib;.\UttecApp;.\UttecProc;.\sensor;.\Simulation
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DCMSIS_VECTAB_VIRTUAL,-DNRF52,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_58,-DNRF52_PAN_55,-DNRF52_PAN_54,-DNRF52_PAN_31,-DNRF52_PAN_30,-DNRF52_PAN_51,-DNRF52_PAN_36,-DNRF52_PAN_53,-DMBED_TICKLESS,-DTARGET_NRF52832,-D__CORTEX_M4,-DS132,-DCONFIG_GPIO_AS_PINRESET,-DBLE_STACK_SUPPORT_REQD,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-DNRF52_PAN_64,-DNRF52_PAN_20,-DNRF52_PAN_62,-DNRF52_PAN_63,-DARM_MATH_CM4
  asm include: .; BLE_API; BLE_API/ble; BLE_API/ble/services; BLE_API/source; BLE_API/source/services; nRF51822; nRF51822/TARGET_NRF5; nRF51822/TARGET_NRF5/source; nRF51822/TARGET_NRF5/source/btle; nRF51822/TARGET_NRF5/source/btle/custom; nRF51822/TARGET_NRF5/source/common; mbed/.; mbed/TARGET_NRF52_DK; mbed/TARGET_NRF52_DK/TARGET_NORDIC; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/TARGET_NRF52_DK; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/pwm; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/saadc; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/nrf52; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/hex; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk_patch; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common; mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler; mbed/TARGET_NRF52_DK/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NRF52_DK/TOOLCHAIN_ARM_STD/nRF52832.sct
  link misc: --show_full_path
  group main
    ./: mbed_config.h
    ./: newMain.cpp
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NRF52_DK/TOOLCHAIN_ARM_STD/: analogin_api.o app_error.o app_error_weak.o app_pwm.o app_scheduler.o app_trace.o app_util_platform.o ble_advdata.o ble_advertising.o ble_conn_state.o ble_db_discovery.o ble_debug_assert_handler.o ble_dfu.o ble_dtm.o ble_flash.o ble_racp.o ble_radio_notification.o ble_srv_common.o bootloader_util.o cmsis_nvic.o crc16.o device_manager_peripheral.o dfu_app_handler.o dfu_init_template.o fds.o flash_api.o fstorage.o fstorage_nosd.o gatt_cache_manager.o gattc_cache_manager.o gatts_cache_manager.o gpio_api.o hci_mem_pool.o i2c_api.o id_manager.o lp_ticker.o mbed.ar mbed_board.o mbed_retarget.o mbed_sdk_boot.o nordic_critical.o nrf_adc.o nrf_assert.o nrf_delay.o nrf_drv_clock.o nrf_drv_common.o nrf_drv_gpiote.o nrf_drv_ppi.o nrf_drv_pwm.o nrf_drv_saadc.o nrf_drv_spi.o nrf_drv_spis.o nrf_drv_timer.o nrf_ecb.o nrf_log.o nrf_nvmc.o nrf_saadc.o peer_data.o peer_data_storage.o peer_database.o peer_id.o peer_manager.o pinmap.o pm_buffer.o pm_mutex.o port_api.o pstorage.o pwmout_api.o reloc_vector_table.o rtc_api.o sdk_mapped_flags.o security_dispatcher.o security_manager.o serial_api.o sleep.o softdevice_handler.o softdevice_handler_appsh.o spi_api.o startup_nrf52832.o system_nrf52.o trng_api.o us_ticker.o
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler/: ant_stack_handler_types.h app_ram_base.h ble_stack_handler_types.h softdevice_handler.h softdevice_handler_appsh.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util/: app_error.h app_error_weak.h app_util.h app_util_bds.h app_util_platform.h common.h nordic_common.h nrf_assert.h nrf_log.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.h sdk_os.h sdk_resources.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm/: app_pwm.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler/: app_scheduler.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace/: app_trace.h
    mbed/TARGET_NRF52_DK/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common/: ble_advdata.h ble_conn_params.h ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising/: ble_advertising.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery/: ble_db_discovery.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler/: ble_debug_assert_handler.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu/: ble_dfu.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm/: ble_dtm.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log/: ble_error_log.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash/: ble_flash.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp/: ble_racp.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification/: ble_radio_notification.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/: bootloader.h bootloader_settings.h bootloader_types.h bootloader_util.h dfu.h dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_transport.h dfu_types.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device/: cmsis.h cmsis_nvic.h system_nrf52.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/: common_rtc.h gpio_object.h irq_handlers_hw.h nrf5x_lf_clk_helper.h objects.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf52.h nrf52_bitfields.h nrf52_name_change.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16/: crc16.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/TARGET_NRF52_DK/: device.h PinNames.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/: device_manager.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config/: device_manager_cnfg.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/: fds.h fds_internal_defs.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config/: fds_config.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/: fstorage.h fstorage_internal_defs.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config/: fstorage_config.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager/: gatt_cache_manager.h gattc_cache_manager.h gatts_cache_manager.h id_manager.h peer_data.h peer_data_storage.h peer_database.h peer_id.h peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.h pm_mutex.h security_dispatcher.h security_manager.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/: hci_mem_pool.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h hci_transport_config.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config/: hci_mem_pool_internal.h hci_transport_config.h
    mbed/: mbed.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/: mbed_rtx.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal/: nrf_adc.h nrf_clock.h nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.h nrf_pdm.h nrf_ppi.h nrf_pwm.h nrf_rtc.h nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_uart.h nrf_wdt.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/: nrf_ble.h nrf_ble_err.h nrf_ble_gap.h nrf_ble_gatt.h nrf_ble_gattc.h nrf_ble_gatts.h nrf_ble_hci.h nrf_ble_l2cap.h nrf_ble_ranges.h nrf_ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay/: nrf_delay.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock/: nrf_drv_clock.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common/: nrf_drv_common.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/: nrf_drv_config.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config/: nrf_drv_config_validation.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote/: nrf_drv_gpiote.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi/: nrf_drv_ppi.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/pwm/: nrf_drv_pwm.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/saadc/: nrf_drv_saadc.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master/: nrf_drv_spi.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave/: nrf_drv_spis.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer/: nrf_drv_timer.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/nrf52/: nrf_mbr.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/: PeripheralNames.h PortNames.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/: pstorage.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config/: pstorage_platform.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk_patch/: sdk_config.h
    mbed/TARGET_NRF52_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars/: section_vars.h
  group UttecLib
    ./UttecLib/: Rf.cpp radio_config.c Flash.cpp rs485.cpp Rcu.cpp modBus.cpp
  group UttecApp
    ./UttecApp/: DimmerRf.cpp UttecLed.cpp mSecExe.cpp UttecUtil.cpp
  group ref
    ./ref/: ref.txt
  group procs
    ./UttecProc/: proc485.cpp procBle.cpp procRf.cpp procSec.cpp procServer.cpp procSx1276.cpp schedule.cpp test.cpp comErr.cpp monitor.cpp
  group Simulation
    ./Simulation/: UttecBle.cpp simSx.cpp
  group sensor
    ./sensor/: pirAnalog.cpp volume.cpp photoAnalog.cpp BH1750.cpp Pyd1788.cpp eprom.cpp HX711.cpp dac.cpp temperature.cpp Rand.cpp
